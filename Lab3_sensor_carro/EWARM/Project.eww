<?xml version="1.0" encoding="UTF-8"?>
<workspace>
  <project>
    <path>$WS_DIR$\Lab3_sensor_carro.ewp</path>
  </project>
  <batchBuild />
</workspace>
